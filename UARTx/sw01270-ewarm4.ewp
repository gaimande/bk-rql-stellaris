# IAR project sw01270-ewarm4.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3Sx7xx Luminary LM3Sx7xx
  ICCARM.CCDefines: ewarm; PART_LM3S3748; TARGET_IS_DUSTDEVIL_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..
  XLINK.XclFile: sw01270-ewarm4.xcl
  group Libraries
    ../../driverlib/ewarm/Exe/: driverlib.r79
  group Source
    ./: startup_ewarm4.c sw01270.c sw_uart_basic.c
