# Keil uVision project sw01270.uvproj, settings and files
target sw01270 (ARM-ADS)
  device: LM3S9790 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sw01270 +hex
  AfterMake: fromelf --bin --output .\rvmdk\sw01270.bin .\rvmdk\sw01270.axf
  c flags: Optim=3 oTime=1 wLevel=2
  c define: rvmdk PART_LM3S39790 TARGET_IS_TEMPEST_RC3
  c include: ..\..;C:\StellarisWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: sw01270.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S
    ./: sw01270.c sw_uart_basic.c
  group Libraries
    C:/StellarisWare/driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
