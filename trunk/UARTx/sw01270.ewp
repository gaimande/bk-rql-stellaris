# IAR project sw01270.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx7xx Luminary LM3Sx7xx
  ICCARM.CCDefines: ewarm; PART_LM3S3748; TARGET_IS_DUSTDEVIL_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: sw01270.bin
  ILINK.IlinkOutputFile: sw01270.out
  ILINK.IlinkIcfFile: sw01270.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: startup_ewarm.c sw01270.c sw_uart_basic.c
