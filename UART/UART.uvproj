# Keil uVision project UART.uvproj, settings and files
target UART (ARM-ADS)
  device: LM3S9790 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UART +hex
  AfterMake: fromelf --bin --output .\output\UART.bin .\output\UART.axf
  c flags: Optim=3 OneElfS=1
  c define: ouput PART_LM3S9790 TARGET_IS_TEMPEST_RC3
  c include: C:\StellarisWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: UART.sct
  link misc: --entry Reset_Handler
  group Source
    ./: Startup.s UART.c
    C:/StellarisWare/utils/: uartstdio.c
  group Library
    C:/StellarisWare/driverlib/rvmdk-cm3/: driverlib-cm3.lib
    C:/StellarisWare/grlib/rvmdk-cm3/: grlib-cm3.lib
